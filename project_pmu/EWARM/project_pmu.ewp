# IAR project project_pmu.ewp, settings and files
configuration project_pmu (ARM, debug)
  General.OGChipSelectEditMenu: STM32G431KB ST STM32G431KB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32G431xx; ARM_MATH_CM4; UAVCAN_NODE_PMU
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32G4xx_HAL_Driver/Inc; ../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../Drivers/CMSIS/Device/ST/STM32G4xx/Include; ../Drivers/CMSIS/Include; ..\..\library\canard\dsdlc_generated; ..\..\library\canard; ..\..\library\cplusplus; ..\..\library\misc; ..\..\library\queue; ..\..\library\ringbuffer; ..\..\library\uthash; ..\..\modules\debug; ..\..\modules\flashfs; ..\..\modules\ipc; ..\..\modules\mavlink\mavlink_generate; ..\..\modules\param; ..\..\modules\uperf; ..; ..\param; ..\..\bsp; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2; ..\..\modules\mavlink; ..\..\library\conversion; ..\..\library\dsp
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ..\Core\Inc
  OBJCOPY.OOCOutputFile: project_pmu.hex
  ILINK.IlinkOutputFile: project_pmu.out
  ILINK.IlinkIcfFile: stm32g431xx_flash.icf
  ILINK.IlinkAdditionalLibs: ..\..\library\dsp\iar_cortexM4lf_math.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32g431xx.s
  group Application/User/Core
    ../Core/Src/: app_freertos.c main.c stm32g4xx_hal_msp.c stm32g4xx_hal_timebase_tim.c stm32g4xx_it.c
  group BSP
    ../../bsp/: can.c delay.c hrt_timer.c i2c.c ist8310.c ncp5623c.c platform.c serial.c spi.c tfmini.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal.c stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_exti.c stm32g4xx_hal_fdcan.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_i2c.c stm32g4xx_hal_i2c_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c stm32g4xx_ll_adc.c
  group Library/convert
    ../../library/conversion/: rotation.c
  group Library/cplusplus
    ../../library/cplusplus/: crt.cpp
  group Library/misc
    ../../library/misc/: crc.c crc32.c utils.c
  group Library/queue
    ../../library/queue/: dq_addafter.c dq_addbefore.c dq_addfirst.c dq_addlast.c dq_cat.c dq_count.c dq_rem.c dq_remfirst.c dq_remlast.c sq_addafter.c sq_addfirst.c sq_addlast.c sq_cat.c sq_count.c sq_rem.c sq_remafter.c sq_remfirst.c sq_remlast.c
  group Library/ringbuffer
    ../../library/ringbuffer/: ringbuffer.c ringbuffer_cpp.cpp
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Modules/canard
    ../../library/canard/: canard.c canard_dsdl.c canard_scalar.c
  group Modules/debug
    ../../modules/debug/: SEGGER_RTT.c SEGGER_RTT_Printf.c
  group Modules/flashfs
    ../../modules/flashfs/: flashfs.c tinybson.c
  group Modules/ipc
    ../../modules/ipc/: ipccore.cpp ipchelper.cpp ipcmain.cpp ipcpull.cpp ipcpush.cpp topics_common.cpp
  group Modules/ipc/topics
    ../../modules/ipc/topics/: actuator_notify.h battery_status.h calibrate_status.h command.h gps_dump.h gps_inject_data.h parameter_update.h satellite_info.h sensor_airspeed.h sensor_baro.h sensor_distance.h sensor_gps.h sensor_mag.h sensor_oflow.h telemetry_status.h uavcan_command_request.h uavcan_command_response.h uavcan_parameter_request.h uavcan_parameter_value.h
  group Modules/mavlink
    ../../modules/mavlink/: mavlink_logs.cpp
  group Modules/param
    ../param/: buildin_parameter.c
    ../../modules/param/: param.c
  group Modules/perf
    ../../modules/uperf/: uPerf.c
  group Src
    ../: startup_task.c
  group Src/battery
    ../../src/battery/: battery.cpp
  group Src/canlink
    ../../src/canlink/: canlink.cpp canlink_messages.cpp canlink_parameter.cpp canlink_stream.cpp canlink_subscription.cpp
  group Src/compass
    ../../src/sensor_mag/: compass.cpp
  group Src/gps
    ../../src/sensor_gps/: gps.cpp
  group Src/gps/device
    ../../src/sensor_gps/device/: ashtech.cpp emlid_reach.cpp femtomes.cpp gps_helper.cpp mtk.cpp rtcm.cpp sbf.cpp ubx.cpp
  group Src/notify
    ../../src/notify/: led.cpp
  group Src/ringfinder
    ../../src/sensor_rng/: ringfinder.cpp
  group Src/shell
    ../../src/shell/: shell.cpp
  group Src/telemetry
    ../../src/telemetry/: mavlink_main.cpp mavlink_messages.cpp mavlink_orb_subscription.cpp mavlink_receiver.cpp mavlink_stream.cpp
